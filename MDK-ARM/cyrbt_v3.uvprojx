# Keil uVision project cyrbt_v3.uvprojx, settings and files
target cyrbt_v3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cyrbt_v3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group cylib
    ../cylib/: cylib.c cylib.h
  group cylib/buffer
    ../cylib/buffer/: cylib_ringbuffer.c cylib_ringbuffer.h
  group cylib/gcoder
    ../cylib/gcoder/: cylib_gcoder.c cylib_gcoder.h
  group cylib/motor
    ../cylib/motor/: cylib_step_motor.c cylib_step_motor.h
  group cylib/serial
    ../cylib/serial/: cylib_serial.c cylib_serial.h
  group cylib/can
    ../cylib/can/: cylib_can.c cylib_can.h
  group cylib/angle
    ../cylib/angle/: cylib_angle.c cylib_angle.h
  group ctlib/switch
    ../cylib/switch/: cylib_switch.c cylib_switch.h
  group cylib/abb
    ../cylib/abb/: cylib_abb.c cylib_abb.h
  group cylib/location
    ../cylib/location/: cylib_location.c cylib_location.h
  group cylib/controller
    ../cylib/controller/: cylib_controller.c cylib_controller.h
  group cylib/b
    ../cylib/b/: b.c b.h
  group cylib/delta
    ../cylib/delta/: delta.c delta.h
software components: CMSIS:CORE 4.3.0
